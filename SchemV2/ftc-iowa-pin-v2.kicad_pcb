# Repository jvens/ftc-iowa-pin

File README.md:

# FTC Iowa Pin

## Description
The FTC Iowa Pin is a small lapel pin in the shape of Iowa containing 24 low power LEDs making the FIRST logo.  The controler is a 8-bit PIC microcontroller made by Microchip.  The power comes from a single CR2032 battery giving the pin XX hours of continous use before the battery needs to be changed.  

## Hardware
The hardware can be split into three main sections: power, LED drivers, and MCU.  There are many ways that the circuit can be populated for various battery life to cost tradeoffs.  These will be better documented after the boards have been fully tested.  

### Power
The main power comes from a single CR2032 Lithium-Ion battery providing 225mA-hr of energy.  The battery supplies a voltage of 2-3 volts nominally which directly powers the MCU circuity (ToDo: add ability to use an LDO if I need a 1.8 V regulated supply).  The battery also drives the step up circuity which is made up of a boost regulator and optional charge pump.  The circuit contains pads for two different boost options and one charge pump options, and jumpers to choose between options.  The output of the step up circuit is 6 volts which is used to power the LED drivers.

### LED Drivers
The LEDs are grouped into 12 sets.  Each set has two LEDs in series.  The sets are grouped into two columns of six rows.  The columns connect Anodes and rows connect Cathodes of the LEDs.  Driving each Anode is a PMOS transistor.  The transistor can be used as a binary switch or an current limiting switch.  When used as a binary switch the pullup resistor turns the switch off when the MCU puts the line to high-Z, and the switch turns on when the MCU drives the line low.  When used as a current limiting switch the MCU outputs an analog voltage using its internal DAC which is amplified by the op-amps to drive the gate.  Each LED is turned on by driving its column high and its row low, and turned off by setting the row to high-Z.

### MCU
The MCU is a PIC16 made by Microchip.  It uses GPIOs to drive the LED rows, and either GPIO or DAC to drive the LED columns.  It also contains a UART Rx line for reprogramming, ICSP for initial programming, and power on reset circuit.  User interaction is done by a capacitive touch pad connecting to the MCU comparator.  The other side of the comparator is driven by the internal DAC to measure the charge time of the touch pad and parallel capacitance.

## Software
ToDo

## KiCad design SchemV2/ftc-iowa-pin-v2.kicad_pcb

Parts:
B101: CR2032
C102, C103, C104: 10uF
C106: TOUCH
C107: 4.7uF
C108, C109: 100nF
C110: 220nF
D101, D102, D103, D104, D105, D106, D107, D108: RED
D109, D110, D111, D112, D113, D114, D115, D116: WHITE
D117, D118, D119, D120, D121, D122, D123, D124: BLUE
L101: 4.7uH
Q101, Q102: BSS84
R101, R107, R109: 0Ω
R102, R103, R110: 1MΩ
R104: 4.3MΩ
R105, R108: 420Ω
R106: 390kΩ
R111, R113, R114, R115: 620Ω
R112: 4.7kΩ
SW101: POWER
TP101: V6P0
TP102: VEXT
TP103: VSYS
TP104: ICSPDAT
TP105: ICSPCLK
TP106: GND
TP107: nMCLR
TP108: RX
U101: TPS61220
U102: PIC16LF1704

Connections:
/BLUE0: R114.2, U102.2 (RA4)
/BLUE1: R115.2, U102.1 (RA5)
/BOOST_VSYS: C102.1, L101.1, R107.2, U101.1 (VIN), U101.6 (EN)
/CAPTOUCH: C106.1, C109.1, R110.1, U102.6 (RC3)
/ICSPCLK: TP105.1, U102.11 (RA1)
/ICSPDAT: Q101.G, R102.1, TP104.1, U102.12 (RA0)
/LED_V6P0: Q101.S, Q102.S, R101.2, R102.2, R103.2
/MCU_VSYS: C107.1, C108.1, R109.1, R110.2, R112.2, U102.14 (VDD)
/RED0: R105.2, U102.9 (RC0)
/RED1: R108.2, U102.8 (RC1)
/RX: TP108.1, U102.4 (RC5)
/SEL0_ANODE: D102.1 (A), D106.1 (A), D110.1 (A), D114.1 (A), D118.1 (A), D122.1 (A), Q101.D
/SEL1: Q102.G, R103.1, U102.10 (RA2)
/SEL1_ANODE: D104.1 (A), D108.1 (A), D112.1 (A), D116.1 (A), D120.1 (A), D124.1 (A), Q102.D
/V6P0: C103.1, C104.1, R101.1, R104.2, TP101.1, U101.4 (VOUT)
/VBATT: B101.1, SW101.1
/VEXT: SW101.3, TP102.1
/VSYS: R107.1, R109.2, SW101.2, TP103.1
/WHITE0: R111.2, U102.7 (RC2)
/WHITE1: R113.2, U102.5 (RC4)
/nMCLR: C110.2, R112.1, TP107.1, U102.3 (RA3)
GND: B101.2, C102.2, C103.2, C104.2, C107.2, C108.2, C109.2, C110.1, R106.1, TP106.1, U101.3 (GND), U102.13 (VSS)
unnamed: L101.2, U101.5 (L)
unnamed: D121.2 (K), D123.2 (K), R115.1
unnamed: D121.1 (A), D122.2 (K)
unnamed: D117.2 (K), D119.2 (K), R114.1
unnamed: D119.1 (A), D120.2 (K)
unnamed: D123.1 (A), D124.2 (K)
unnamed: D115.1 (A), D116.2 (K)
unnamed: D113.2 (K), D115.2 (K), R113.1
unnamed: D113.1 (A), D114.2 (K)
unnamed: D109.2 (K), D111.2 (K), R111.1
unnamed: D111.1 (A), D112.2 (K)
unnamed: D105.2 (K), D107.2 (K), R108.1
unnamed: D107.1 (A), D108.2 (K)
unnamed: D105.1 (A), D106.2 (K)
unnamed: D101.2 (K), D103.2 (K), R105.1
unnamed: D103.1 (A), D104.2 (K)
unnamed: D117.1 (A), D118.2 (K)
unnamed: D109.1 (A), D110.2 (K)
unnamed: D101.1 (A), D102.2 (K)
unnamed: R104.1, R106.2, U101.2 (VFB)

Board: 2 copper layers, 37.9 x 24.3 mm, 62 parts (37 on the bottom side), 42 nets.

## KiCad design schematic/ftc-iowa-pin.kicad_pcb

Parts:
B101: CR2032
C101, C105: 4.7uF
C102, C103, C104, C110, C111: 10uF
C106: 100nF
C107: TOUCH
C108: 10nF
C109: 220nF
D101, D102, D103, D104, D105, D106, D107, D108: RED
D109, D110, D111, D112, D113, D114, D115, D116: WHITE
D117, D118, D119, D120, D121, D122, D123, D124: BLUE
D125: DIODE
L101: 4.7uH
Q101, Q102: PMOS
R101, R104: 470kΩ
R102, R110: 220kΩ
R103, R106, R111: 390kΩ
R105, R107, R108, R112, R113, R114, R115, R116, R117, R119, R120, R122, R123: 0Ω
R109: 110kΩ
R118: 1MΩ
R121: 4.7kΩ
SW101: POWER
TP101: V5P5
TP102: VBATT
TP103: GND
TP104: ICSPDAT
TP105: ICSPCLK
TP106: nMCLR
TP107: RX
U101: MCP6442
U102: MCP1624
U103: PIC16LF1704
U104: LM2767
U105: TPS61220

Connections:
/BLUE0: R119.1, U103.1 (RA5)
/BLUE1: R120.1, U103.2 (RA4)
/RED0: R108.1, U103.9 (RC0)
/RED1: R114.1, U103.8 (RC1)
/SEL0: Q102.1 (Gate), R104.2, R111.2, R113.2, U101.1 (OUT)
/SEL1: Q101.1 (Gate), R101.2, R103.2, R107.2, U101.7 (OUT)
/WHITE0: R116.1, U103.7 (RC2)
/WHITE1: R117.1, U103.5 (RC4)
GND: B101.2 (-), C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C108.2, C109.2, C110.2, R102.1, R109.1, R110.1, TP103.1, U101.4 (VSS), U102.2 (SGND), U102.3 (PGND), U102.9 (EP), U103.13 (VSS), U104.2 (GND), U105.3 (GND)
unnamed: C101.1, L101.1, R112.2, U102.4 (EN), U102.8 (VIN), U105.1 (VIN), U105.6 (EN)
unnamed: L101.2, U102.5 (SW), U105.5 (L)
unnamed: R113.1, TP104.1, U101.3 (+), U103.12 (RA0)
unnamed: R112.1, R115.1, SW101.1, TP102.1
unnamed: B101.1 (+), SW101.2
unnamed: R110.2, R111.1, U101.2 (-)
unnamed: R107.1, U101.5 (+), U103.10 (RA2)
unnamed: C107.1, C108.1, R118.1, U103.6 (RC3)
unnamed: R102.2, R103.1, U101.6 (-)
unnamed: TP107.1, U103.4 (RC5)
unnamed: TP105.1, U103.11 (RA1)
unnamed: R106.1, R109.2, U102.1 (VFB), U105.2 (VFB)
unnamed: C111.1, U104.5 (CAP+)
unnamed: C111.2, U104.3 (CAP-)
unnamed: D125.1 (A), R123.2, U104.4 (VIN)
unnamed: C110.1, D125.2 (K), R122.1, U104.1 (VOUT)
unnamed: D113.2 (K), D115.1 (A)
unnamed: C109.1, R121.1, TP106.1, U103.3 (RA3)
unnamed: C103.1, C104.1, Q101.2 (SOURCE), Q102.2 (SOURCE), R101.1, R104.1, R105.2, R122.2, TP101.1, U101.8 (VDD)
unnamed: D114.2 (K), D116.1 (A)
unnamed: C105.1, C106.1, R115.2, R118.2, R121.2, U103.14 (VDD)
unnamed: C102.1, R105.1, R106.2, R123.1, U102.6 (VOUTP), U102.7 (VOUTS), U105.4 (VOUT)
unnamed: D106.2 (K), D108.1 (A)
unnamed: D109.2 (K), D111.1 (A)
unnamed: D117.2 (K), D119.1 (A)
unnamed: D104.2 (K), D120.2 (K), R119.2
unnamed: D101.2 (K), D103.1 (A)
unnamed: D105.2 (K), D107.1 (A)
unnamed: D102.2 (K), D104.1 (A)
unnamed: D108.2 (K), D124.2 (K), R117.2
unnamed: D111.2 (K), D112.2 (K), R116.2
unnamed: D115.2 (K), D116.2 (K), R120.2
unnamed: D121.2 (K), D123.1 (A)
unnamed: D107.2 (K), D123.2 (K), R114.2
unnamed: D103.2 (K), D119.2 (K), R108.2
unnamed: D122.2 (K), D124.1 (A)
unnamed: D109.1 (A), D113.1 (A), D117.1 (A), D118.1 (A), D121.1 (A), D122.1 (A), Q101.3 (DRAIN)
unnamed: D101.1 (A), D102.1 (A), D105.1 (A), D106.1 (A), D110.1 (A), D114.1 (A), Q102.3 (DRAIN)
unnamed: D110.2 (K), D112.1 (A)
unnamed: D118.2 (K), D120.1 (A)

Notes on the sheet:
VFB=1.21V

Board: 2 copper layers, 172.2 x 99.6 mm, 79 parts (51 on the bottom side), 49 nets.

Other parts of the board:
VAL: REF; iowa_small
VAL#2: REF; iowa_50mm
VAL#3: REF; first_rotate_resize
VAL#4: REF; first_color

## Code that names these connections

File code/main.c (part):

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/// The GPIOs for this project
const struct gpio_pin gpios[] = 
{
    {&GPIOA, 0}, // SEL0
    {&GPIOA, 1}, // SEL1
    {&GPIOC, 0}, // RED0
    {&GPIOC, 1}, // RED1
    {&GPIOC, 2}, // WHITE0
    {&GPIOC, 4}, // WHITE1
    {&GPIOA, 4}, // BLUE0
    {&GPIOA, 5}  // BLUE1
};

typedef enum gpio_mode
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
void led_init()
{
    gpio_setMode(SEL0, HIGHZ);
    gpio_setMode(SEL1, HIGHZ);
    gpio_setMode(RED0, HIGHZ);
    gpio_setMode(RED1, HIGHZ);
    gpio_setMode(WHITE0, HIGHZ);
    gpio_setMode(WHITE1, HIGHZ);
    gpio_setMode(BLUE0, HIGHZ);
    gpio_setMode(BLUE1, HIGHZ);
    
    gpio_setPullup(SEL0, false);
    gpio_setPullup(SEL1, false);
    gpio_setPullup(RED0, false);
    gpio_setPullup(RED1, false);
    gpio_setPullup(WHITE0, false);
    gpio_setPullup(WHITE1, false);
    gpio_setPullup(BLUE0, false);
    gpio_setPullup(BLUE1, false);
    
    gpio_setOpenDrain(SEL0, true);
    gpio_setOpenDrain(SEL1, true);
    gpio_setOpenDrain(RED0, true);
    gpio_setOpenDrain(RED1, true);
    gpio_setOpenDrain(WHITE0, true);
    gpio_setOpenDrain(WHITE1, true);
    gpio_setOpenDrain(BLUE0, true);
    gpio_setOpenDrain(BLUE1, true);
    
    gpio_setValue(SEL0, LOW);
    gpio_setValue(SEL1, LOW);
    gpio_setValue(RED0, LOW);
    gpio_setValue(RED1, LOW);
    gpio_setValue(WHITE0, LOW);
    gpio_setValue(WHITE1, LOW);
    gpio_setValue(BLUE0, LOW);
    gpio_setValue(BLUE1, LOW);
}

void led_turnOff(gpio g)
{
    gpio_setMode(g, HIGHZ);
    gpio_setMode(SEL0, HIGHZ);
    gpio_setMode(SEL1, HIGHZ);
}

void led_turnOn(gpio g, unsigned char sel0, unsigned char sel1)
{
    gpio_setMode(SEL0, sel0 ? OUTPUT : HIGHZ);
    gpio_setMode(SEL1, sel1 ? OUTPUT : HIGHZ);
    gpio_setMode(g, OUTPUT);
}

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
## Commit log

2015-10-17 schematic
2015-11-01 Pushing second version of the schematic for OSH park
2015-11-02 Added copper pour
2015-11-02 cleaned up silk
2015-11-19 code
2015-11-20 Comments on GPIOs
